## Package/buildroot/Config.in
```kconfig
config BR2_PACKAGE_IOPCVM
	bool "iopcvm"
	select BR2_PACKAGE_LIBIOPCCOMMON
	help
	  IOPC message queue util.
```
